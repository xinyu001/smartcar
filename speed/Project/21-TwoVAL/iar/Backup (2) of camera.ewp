# IAR project Backup (2) of camera.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK60DN512Zxxx10 Freescale MK60DN512Zxxx10
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: ARM_MATH_CM4; MK60DZ10; IAR
  ICCARM.CCIncludePath2: E:\CHIP\smartcar\FREESCAR\PROGRAM\3333\K60_OV77\Lib\Chip\src; E:\CHIP\smartcar\FREESCAR\PROGRAM\3333\K60_OV77\Lib\Chip\src\IAR; E:\CHIP\smartcar\FREESCAR\PROGRAM\3333\K60_OV77\Lib\Chip\inc; E:\CHIP\smartcar\FREESCAR\PROGRAM\3333\K60_OV77\Lib\Chip\inc\IAR; E:\CHIP\smartcar\FREESCAR\PROGRAM\3333\K60_OV77\Lib\Chip\inc\kinetis; E:\CHIP\smartcar\FREESCAR\PROGRAM\3333\K60_OV77\Lib\CMSIS; E:\CHIP\smartcar\FREESCAR\PROGRAM\3333\K60_OV77\Lib\CMSIS\inc; E:\CHIP\smartcar\FREESCAR\PROGRAM\3333\K60_OV77\Lib\Driver; E:\CHIP\smartcar\FREESCAR\PROGRAM\3333\K60_OV77\Lib\fatfs; E:\CHIP\smartcar\FREESCAR\PROGRAM\3333\K60_OV77\Project\21-TwoVAL\app; E:\CHIP\smartcar\FREESCAR\PROGRAM\3333\K60_OV77\Project\21-TwoVAL\app\inc; E:\CHIP\smartcar\FREESCAR\PROGRAM\3333\K60_OV77\Project\21-TwoVAL\Driver; E:\CHIP\smartcar\FREESCAR\PROGRAM\3333\K60_OV77\Project\21-TwoVAL\iar
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: helloworld.srec
  ILINK.IlinkOutputFile: mydemo.out
  ILINK.IlinkIcfFile: E:\CHIP\smartcar\FREESCAR\PROGRAM\3333\K60_OV77\Lib\icf_files\512KB_Pflash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group app
    ../Driver/: function.c function.h
    ../app/: main.c
  group Driver
    ../Driver/: button.c camera.c control.c debug.c eeprom.c fuzzy.c I2C.c led.c oled12864.c SCCB.c search.c
  group lib
    ../../../Lib/Chip/src/: MK60_adc.c MK60_dac.c MK60_dma.c MK60_DWT.c MK60_flash.c MK60_ftm.c MK60_gpio.c MK60_i2c.c MK60_lptmr.c MK60_mcg.c MK60_PIT.c MK60_port.c MK60_rtc.c MK60_spi.c MK60_SysTick.c MK60_uart.c MK60_wdog.c
  group system
    ../../../Lib/Chip/inc/: common.h
    ../app/inc/: include.h MK60_conf.h PORT_cfg.h
    ../../../Lib/Chip/src/: misc.c vectors.c
    ../app/: MK60_conf.c
    ../../../Lib/Chip/src/IAR/: startup_MK60DZ10.s system_MK60DZ10.c
