# IAR project camera.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK60DN512Zxxx10 Freescale MK60DN512Zxxx10
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: ARM_MATH_CM4; MK60DZ10; IAR
  ICCARM.CCIncludePath2: D:\github clone\smartcar\speed\Lib\Chip\src; D:\github clone\smartcar\speed\Lib\Chip\src\IAR; D:\github clone\smartcar\speed\Lib\Chip\inc; D:\github clone\smartcar\speed\Lib\Chip\inc\IAR; D:\github clone\smartcar\speed\Lib\Chip\inc\kinetis; D:\github clone\smartcar\speed\Lib\CMSIS; D:\github clone\smartcar\speed\Lib\CMSIS\inc; D:\github clone\smartcar\speed\Lib\Driver; D:\github clone\smartcar\speed\Lib\fatfs; D:\github clone\smartcar\speed\Project\21-TwoVAL\app; D:\github clone\smartcar\speed\Project\21-TwoVAL\app\inc; D:\github clone\smartcar\speed\Project\21-TwoVAL\Driver; D:\github clone\smartcar\speed\Project\21-TwoVAL\iar
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: camera.bin
  ILINK.IlinkOutputFile: camera.out
  ILINK.IlinkIcfFile: D:\github clone\smartcar\speed\Lib\icf_files\512KB_Pflash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group app
    ../Driver/: function.c function.h
    ../app/: main.c
  group Driver
    ../Driver/: button.c camera.c control.c debug.c eeprom.c fuzzy.c I2C.c led.c oled12864.c SCCB.c search.c
  group lib
    ../../../Lib/Chip/src/: MK60_adc.c MK60_dac.c MK60_dma.c MK60_DWT.c MK60_flash.c MK60_ftm.c MK60_gpio.c MK60_i2c.c MK60_lptmr.c MK60_mcg.c MK60_PIT.c MK60_port.c MK60_rtc.c MK60_spi.c MK60_SysTick.c MK60_uart.c MK60_wdog.c
  group system
    ../../../Lib/Chip/inc/: common.h
    ../app/inc/: include.h MK60_conf.h PORT_cfg.h
    ../../../Lib/Chip/src/: misc.c vectors.c
    ../app/: MK60_conf.c
    ../../../Lib/Chip/src/IAR/: startup_MK60DZ10.s system_MK60DZ10.c
